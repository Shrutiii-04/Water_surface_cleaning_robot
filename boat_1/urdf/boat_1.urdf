Commit message: Initial Commit

File: boat_1/urdf/boat_1.urdf (robot description, URDF)
Before this commit: robot boat_1, 5 links, 4 joints
Joints:
- joint lidar_joint: origin xyz=0.75 0.0 1.4 rpy=0 0 0 -> xyz=0.75 0.0 0.960 rpy=0 0 0
